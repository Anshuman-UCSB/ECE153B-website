# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: LED.c LED.h main.c startup_stm32l476xx.s stm32l476xx.h SysClock.c SysClock.h BUTTON.c BUTTON.h SysTimer.c SysTimer.h RNG.c RNG.h SPI.c SPI.h UART.c UART.h UART_printf.c OLED.c OLED.h hash.h PWM.c PWM.h Config.c Config.h
software components: CMSIS:CORE 5.5.0
